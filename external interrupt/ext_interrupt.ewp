# IAR project ext_interrupt.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F2P STM8S103F2P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: User; Libraries\inc; ..\..\HN_Lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ext_interrupt.hex
  ILINK.IlinkOutputFile: ext_interrupt.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    ../../HN_Lib/: stm8s103.c stm8s103.h
    Libraries/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim2.c stm8s_tim4.c
  group User
    User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h

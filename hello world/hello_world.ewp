# IAR project hello_world.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F2P STM8S103F2P
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\HN_Lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: hello_world.hex
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Libraries
    ../../HN_Lib/: stm8s103.c stm8s103.h
    ../../STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c
  group User
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h

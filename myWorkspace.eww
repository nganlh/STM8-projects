<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ADC\ADC.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\delay using timer\delay.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\UART\uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
